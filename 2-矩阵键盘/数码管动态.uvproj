# Keil uVision project 数码管动态.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89F52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: 数码管动态
  c flags: Optimize=8 SizeSpeed=1
